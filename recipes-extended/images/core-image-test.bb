require recipes-core/images/core-image-minimal.bb

IMAGE_INSTALL += "kernel-module-mmsens-drv"
